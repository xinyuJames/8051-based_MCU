# Keil uVision project Serial_communication.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Serial_communication +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c SerialCommunication.c SerialCommunication.h Delay.c Delay.h
