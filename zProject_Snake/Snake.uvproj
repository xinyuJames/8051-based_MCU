# Keil uVision project Snake.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Snake +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c Delay.h Delay_s.c Delay_s.h main.c MatrixKey.c MatrixKey.h MatrixLED.c MatrixLED.h MLED_Lib.c MLED_Lib.h Snake.c Snake.h Timer0.c Timer0.h
