#include <REGX52.H>
#include <INTRINS.H>
#include "MatrixLED.h"

xdata unsigned char A_GAMEOVER[] = {0xFF,0x81,0x89,0x8F,0x00,0x3F,0x48,0x88,0xFF,0x00,0xFF,0x40,0x40,0xFF,0x00,0xFF,
0x89,0x89,0x89,0x00,0x00,0xF0,0x90,0xF0,0x00,0xE0,0x10,0xEF,0x0B,0x09,0x00,0x0F,0x0A,0x0D}; //34 + 16

xdata unsigned char A_SCORE[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x62,0x91,0x89,0x46,0x00,0x7E,0x81,0x81,0x42,0x00,0x7E,0x89,0x91,0x7E,0x00,0x7F,
0x88,0x94,0x63,0x00,0x7E,0x89,0x89,0x42,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}; //28 + 8

xdata unsigned char A_numberList[10][4] = {{0x7E,0x89,0x91,0x7E},{0x21,0x41,0xFF,0x01},{0x47,0x89,0x91,0x61},
{0x42,0x91,0x91,0x7E},{0x18,0x28,0x48,0xFF},{0xF1,0x51,0x51,0x4},{0x7E,0x91,0x91,0x4E},
{0x80,0x8F,0x90,0x60},{0x6E,0x91,0x91,0x6E},{0x62,0x91,0x91,0x7E}};

xdata unsigned char A_TITLE[] = {0x1F,0x2C,0x61,0xE1,0xE1,0x6D,0x20,0x1F,};

//void MLEDShow_HELLO()
//{
//	
//	unsigned int i;
//	unsigned int j;
//	unsigned int rep;
//	for (i = 0; i < 44 - 8; i++)
//	{
//		
//		for (rep = 0; rep < 8; rep++)
//		{
//			for (j = 0; j < 8; j++)
//			{
//				MLED_ShowColumn(j, A_HELLO[j + i]);
//			}
//		}
//	}
//}

void MLEDShow_GAMEOVER()
{
	unsigned int i;
	unsigned int j;
	unsigned int rep;
	for (i = 0; i < 34 - 8; i++)
	{
		for (rep = 0; rep < 8; rep++)
		{
			for (j = 0; j < 8; j++)
			{
				MLED_ShowColumn(j, A_GAMEOVER[j + i]);
			}
		}
	}
}

void MLEDShow_SCORE(unsigned char score)
{
	unsigned int i;
	unsigned int j;
	unsigned int rep;
	
	for (i = 0; i < 34; i++)
	{
		for (rep = 0; rep < 8; rep++)
		{
			for (j = 0; j < 8; j++)
			{
				MLED_ShowColumn(j, A_SCORE[j + i]);
			}
		}
	}
	
	for (rep = 0; rep < 300; rep++)
	{
		for (j = 0; j < 4; j++)
		{
			MLED_ShowColumn(j, A_numberList[score / 10][j]);
		}
		
		for (j = 0; j < 4; j++)
		{
			MLED_ShowColumn(j + 4, A_numberList[score % 10][j]);
		}
	}
}

void MLEDShow_LXY()
{
	unsigned int j;
	unsigned int rep;
	
	for (rep = 0; rep < 10; rep++)
		{
			for (j = 0; j < 8; j++)
			{
				MLED_ShowColumn(j, A_TITLE[j]);
			}
		}
}