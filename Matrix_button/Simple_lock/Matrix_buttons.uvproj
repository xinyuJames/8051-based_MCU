# Keil uVision project Matrix_buttons.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Matrix_buttons +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c Delay.h LCD1602.c LCD1602.h main.c MatrixKey.c MatrixKey.h
